options:
  parameters:
    author: boat
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: vhf
    output_language: python
    title: VHF Scanner
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: python_mod.sweeper(fun_prob1)
  states: {}
- name: fun_prob1
  id: variable_function_probe
  parameters:
    block_id: probSign1
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {}
- name: qtgui_dialgauge_0
  id: qtgui_dialgauge
  parameters:
    maximum: '163_000_000'
    minimum: '161_000_000'
    showValue: 'True'
    type: int
    value: fc
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2_400_000'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48_000'
    max_dev: 5e3
    quad_rate: '480_000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48_000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '150_000_000'
    init: '0'
    low: '100_000_000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '7_500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2_500'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '40'
    freq0: fc
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '32'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: probSign1
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: python_mod
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import sys
      from typing import Final

      F1: Final[int] = 161_000_000
      F2: Final[int] = 163_000_000
      STEP: Final[int] = 25_000
      f = F1

      def sweeper(prob_lvl1):
          global f

          if prob_lvl1 == 0.0:
              f += STEP
          if f >= F2:
              f = F1

          print(prob_lvl1, f)
          return f
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    rate: '5'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    rate: '5'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    type: ccc
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_rms_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_threshold_ff_0, '0', probSign1, '0']
- [blocks_threshold_ff_0, '0', qtgui_number_sink_1, '0']
- [low_pass_filter_0, '0', blocks_rms_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
